# Keil uVision project nrf_advertiser.uvprojx, settings and files
target nRF51822_PCA10028 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.29.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ts_advertiser +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 BSP_DEFINES_ONLY
  c misc: --c99
  c include: ..\Include;..\..\..\..\components\libraries\util;..\..\..\..\components\libraries\fifo;..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\components\toolchain\arm;..\..\..\..\components\toolchain;..\..\..\..\components\ble\common;..\..\..\..\components\ble\device_manager\config;..\..\..\..\components\drivers_nrf\common;..\..\..\..\components\ble\ble_advertising;..\..\..\..\components\softdevice\s110\headers;..\..\..\..\components\drivers_nrf\pstorage\config;..\..\..\bsp;..\..\..\..\components\libraries\trace;..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\components\ble\device_manager;..\..\..\..\components\drivers_nrf\uart;..\..\..\..\components\device;..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\components\libraries\timer;..\..\..\..\components\drivers_nrf\hal;..\..\Include;..\..\btle_hci\advertiser\Include;..\..\btle_hci\fifo\Include;C:\Users\alice\AppData\Local\Arm\Packs\ARM\CMSIS\5.6.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x40000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group app
    ../: main.c nrf_adv_conn.c
  group core
    ../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../components/toolchain/: system_nrf51.c
  group lib
    ../../../../components/libraries/uart/: retarget.c
    ../../../../components/libraries/fifo/: app_fifo.c
  group ble
    ../../../../components/ble/common/: ble_advdata.c
  group drivers
    ../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../components/drivers_nrf/pstorage/: pstorage.c
    ../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group btle_hci
    ../../btle_hci/fifo/: nrf_report_disp.c nrf_report_fifo.c
    ../../btle_hci/advertiser/: nrf_advertiser.c ts_controller.c ts_peripheral.c ts_rng.c ts_whitelist.c
target nRF51822_PCA10031 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.29.0
  cpu: as above
  output: ts_advertiser +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10031 SOFTDEVICE_PRESENT NRF51 BSP_DEFINES_ONLY
  c misc: --c99
  c include: as above
  asm include: ..\..\btle_hci
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x40000
  memory RVCT9: RAM 0x20002000 size 0x6000
